	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA Mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1    ;STORES ADDRESS OF N1 IN R0 i.e- R0=Ox0000 0030
	LDR R1,=N2    ;STORES ADDRESS OF N2 IN R1 i.e- R1=Ox0000 0034
	LDR R2,[R0]		;STORES CONTENT R0 IS POINTING TO i.e- R2=0x0000 0015
	LDR R3,[R1]
	MOV R4,#0		;QUOTIENT
	LDR R6, =result
up  
	CMP R2,R3
	BCC Store    ;BRANCH IF CARRY IS CLEAR
	SUB R2,R3
	ADD R4,#1
	B up
Store 	
	STR R4,[R6],#4   ;R6 STORES THE QUOTIENT(3) IN 0X1000 0000 AND THEN INCREMENTS R6 BY 4  
	STR R2,[R6]		;R6 STORES THE REMAINDER WHICH IS LEFT AFTER THE LAST SUBTRACTION
STOP
	B STOP
N1 DCD 21
N2 DCD 7

	AREA mydata, DATA, READWRITE
result DCD 0,0
		
	END
		